# Keil uVision project TRE_Flowers.uvprojx, settings and files
target TRE_Flowers (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TRE_Flowers +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/src/include;../FreeRTOS/Target/portable/RVDS/ARM_CM4F;../Drivers/User;../System;../Test;../Drivers/HardWare;../Middlewares/Third_Party/Lvgl/master;../Middlewares/Third_Party/Lvgl/master/src;../Lvgl;../GUI/App;../Utils/List;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../FreeRTOS/App;../GUI/Fonts;../Config;../Middlewares/Third_Party/Lvgl/master/src/extra/libs/sjpg;../Middlewares/Third_Party/Lvgl/master/src/extra/libs/png;../Middlewares/Third_Party/Lvgl/master/src/extra/libs/fsdrv;../GUI/Components;../Middlewares/Third_Party/Arduboy/src;../Arduboy_Game/Buttons;../Arduboy_Game/Snake;../Arduboy_Game/FlappyBall;../Arduboy_Game/Dino;../Arduboy_Game/ArduboyTetris;../Middlewares/Third_Party/Nes;../Utils/Utf8;../Utils/Calc;../Utils/Text;../Utils/UTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Config
    ../Config/: app_config.h app_default_config.h
  group Application/User/Core
    ../Core/Inc/: hal_handler.h
    ../Core/Src/: hal_handler.c main.c gpio.c dma.c fsmc.c i2c.c rng.c sdio.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FreeRTOS/App
    ../FreeRTOS/App/: os_task.c
  group Application/User/FreeRTOS/Target
    ../FreeRTOS/Target/portable/MemMang/: heap_4.c
    ../FreeRTOS/Target/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/Lvgl
    ../Lvgl/: lv_port_disp.c lv_port_indev.c
    ../Middlewares/Third_Party/Lvgl/master/: lv_conf.h
  group Application/User/Test
    ../Test/: lcd_test.c sram_test.c lvgl_test.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/src/include/: FreeRTOSConfig.h
  group Middlewares/Lvgl
    ../Middlewares/Third_Party/Lvgl/master/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/Third_Party/Lvgl/master/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/Lvgl/master/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/Lvgl/master/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/Third_Party/Lvgl/master/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/Third_Party/Lvgl/master/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/Third_Party/Lvgl/master/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/Lvgl/Libs
    ../Middlewares/Third_Party/Lvgl/master/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../Middlewares/Third_Party/Lvgl/master/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group Middlewares/Arduboy
    ../Middlewares/Third_Party/Arduboy/src/: arduboy.c arduboy_core.c
  group Middlewares/Nes
    ../Middlewares/Third_Party/Nes/: nes_apu.c nes_crc32.c nes_mapper.c nes_ppu.c nes_main.c 6502.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/HardWare
    ../Drivers/HardWare/: ads1110.c at24cxx.c bmp280.c buzzer.c hdc1080.c key.c lcd_2inch.c libNMEA.c sram.c stm32_ds3231.c tea5767.c vs10xx.c w25q16.c
  group Drivers/User
    ../Drivers/User/: lcd.c player.c recoder.c atgm336h.c fm.c malloc.c device.c
  group GUI/Fonts
    ../GUI/Fonts/: FONT.h songti_zh_16.c font_symbol_14.c font_symbol_32.c font_symbol_def.h MorningGlory.c
  group GUI/Components
    ../GUI/Components/: com_file_expolrer.c com_status_bar.c components.h com_gps_tabview.c canvas_helper.c com_book_menu.c com_book_shelf.c com_adjust_slider.c com_msgbox.c com_arc_load.c com_alarm_list.c
  group GUI/App
    ../GUI/App/: gui_inc.h gui_inc_def.h gui_port.c gui_logo.c gui_main.c gui_apps.c gui_page.c gui_app_about.c gui_app_book.c gui_app_gps.c gui_app_setting.c gui_app_arduboy.c gui_app_calc.c gui_app_calendar.c gui_app_nes.c
  group System
    ../System/: sys.c sys.h
  group Utils/List
    ../Utils/List/: list.c list_iterator.c list_node.c
  group Utils/Utf8
    ../Utils/Utf8/: utf8.c
  group Utils/Calc
    ../Utils/Calc/: calculator.c
  group Utils/UTC
    ../Utils/UTC/: utc.c
  group Arduboy/Button
    ../Arduboy_Game/Buttons/: ArduboyButtons.c
  group Arduboy/Snake
    ../Arduboy_Game/Snake/: Food.cpp Snake.cpp SnakePort.cpp
  group Arduboy/FlappyBall
    ../Arduboy_Game/FlappyBall/: FlappyBall.c
  group Arduboy/Dino
    ../Arduboy_Game/Dino/: Dino.c
software components: CMSIS:CORE 4.3.0
